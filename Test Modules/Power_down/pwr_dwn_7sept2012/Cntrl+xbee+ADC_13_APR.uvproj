# Keil uVision project Cntrl+xbee+ADC_13_APR.uvproj, settings and files
target Target 1 ()
  device: LPC2148 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Cntrl+xbee+ADC_13_APR +hex
  group Source Group 1
    ./: Startup.s adc.c app.c dac.c key.c lcd.c main.c pwm.c rtc.c timer.c uart.c wdt.c
