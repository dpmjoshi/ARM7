# Keil uVision project Timer_Capture _mode.uvproj, settings and files
target Target 1 ()
  device: LPC2148 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Timer_Capture _mode +hex
  group Source Group 1
    ./: Startup.s lcd.c main.c timer.c rtc.c uart.c key.c lib.c dac.c
